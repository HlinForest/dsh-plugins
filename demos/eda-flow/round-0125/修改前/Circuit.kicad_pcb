# Repository HlinForest/dsh-plugins

File README.md:

# DSH Plugins

为 DeepSeek Harness 提供独立工程插件与可视化工作台，目标运行时为 **DSH 0.2.0-rc.2**，要求 **Node.js ≥ 22.19.0**。

**历史预置输入显示板工程（2026-10-15）：** [工程目录与打开说明](examples/display-board-20261015/README.md) · [原理图 PDF](examples/display-board-20261015/DisplayBoard/previews/schematic.pdf) · [工程下载包](https://github.com/HlinForest/dsh-plugins/releases/tag/display-board-20261015)。该目录随 Git 拉取取得，包含原理图、PCB、BOM、库、模型与预览，无需运行插件。本轮从默认数据生成；PCB 数据的历史准备曾使用官方导入器辅助提取，具体范围见说明。

| 插件 | 版本 | 用途 |
| --- | --- | --- |
| [dsh-megmeet](plugins/dsh-megmeet/README.md) | 0.2.0 | 需求解析、资料库检索、工况校验与可追溯报告 |
| [dsh-pcb-review](plugins/dsh-pcb-review/README.md) | 0.1.2 | Altium / KiCad 导出数据评审、器件检查清单与变更提醒 |
| [dsh-schematic-sync](plugins/dsh-schematic-sync/README.md) | 0.1.2 | KiCad 原理图目标对比、候选修改、验证与回退 |
| [dsh-kicad-workflow](plugins/dsh-kicad-workflow/README.md) | 0.1.1 | KiCad MCP 接入、设计与重建流程、检查及交付打包 |
| [dsh-eda-flow](plugins/dsh-eda-flow/README.md) | 0.16.3-beta.18 | 文字/PDF通用设计、工程师评审、真实PCB布局布线与前后验收 |
| [dsh-engineering-workbench](plugins/dsh-engineering-workbench/README.md) | 0.6.0 | 独立窗口与 Harness 风格 UI；保留读手册、产品方案、评审、比较、编辑、资料提取与复原流程 |

## 电路设计 0.16.3-beta.18：文字评审后实跑整板修复

[Demo 与可编辑工程](demos/eda-flow/round-0153/Demo与工程.zip) · [前后核验](demos/eda-flow/round-0153/实际前后核验.json) · [评审记录](demos/eda-flow/round-0153/工程师评审记录.json) · [AD 逐项比较](demos/eda-flow/round-0153/与AD逐项比较.md) · [参数依据](demos/eda-flow/round-0153/参数差异与依据.md) · [使用说明](demos/eda-flow/round-0153/使用说明.md) · [插件 TGZ](dist/dsh-eda-flow-0.16.3-beta.18.tgz)

使用已安装插件和真实 DeepSeek（PCB 5 次、交付 2 次调用）完成当前 27 器件显示板。相对评审开始前，显式线长 **442.34→428.40 mm**，短段 **3→1**，二度折点 **70→57**；27 器件、94 物理焊盘、29/29 信号及全部物理铜形连通，原生 DRC 和原理图一致性问题均为 0。交付副本复检通过。C1 完整回路增加约 0.13 mm，C5/C6 不变，供电脚距离均满足已确认的 10 mm。

新增通用同接收器/回流域滤波组布局，失败或无改善时继续普通压缩；保留完整基线后仍可修复不完整的质量候选，只有全部铜形连通且质量改善才替换。修复失败同时恢复原生文件、导出记录与 SQLite 权威记录。本轮最终采用普通布局候选的局部修复，联合组候选未通过，未采用；开发工具候选 405.96 mm 未在此次正式流程复现，不计入交付改善。

35 项针对性测试通过（含一个非显示板的原理图到 PCB 原生流程），源码/安装包/已安装插件 288 文件一致。使用现有 Freerouting；可选路由调度与跨线质量实验未在正式流程启用。单铜层、有界搜索的结果不能保证任意板一次成功。9 只电阻、2 组电容差异没有减少，IRM 型号后缀及工作条件仍待确认；没有输入 AD 固定坐标、完整逐脚网表或照抄参数。

原理图可点选器件填写要求，保存意见或按要求生成方案后再更新下游；没有具体参数输入时不会擅自替换器件。缺少 KiCad 可先用 ReviewOnly 保存需求与评审，CAD 生成仍需要本机工具。历史待办中仍有重复或已被后续步骤解决的条目，当前验收以本轮图纸和逐项记录为准。

## 历史电路设计 0.16.3-beta.17：补齐封装装配类型与贴片导出

[Demo 与修复版工程](demos/eda-flow/round-0150/Demo与工程.zip) · [评审记录](demos/eda-flow/round-0150/工程师评审记录.json) · [重新读取当前 PCB 的 AD 比较](demos/eda-flow/round-0150/与AD逐项比较.md) · [使用说明](demos/eda-flow/round-0150/使用说明.md) · [插件 TGZ](dist/dsh-eda-flow-0.16.3-beta.17.tgz) · [SHA256](dist/dsh-eda-flow-0.16.3-beta.17.tgz.sha256)

外部封装的焊盘已生成，但遗漏 KiCad 装配类型会让“仅贴片”坐标导出漏掉主芯片。修复从已引用资料的电气焊盘结构确定贴片或插装属性，兼容历史候选同步；不依赖显示板位号或固定坐标。当前完整显示板贴片导出 23 → 24 项（补齐 U1），三个通孔器件标为插装；其他排除导出与不装配属性保留。

本次为 round-0149 已验收整板的确定性元数据修复，新增模型调用 0 次。原生文件除四个装配类型外结构完全相同，重新 DRC 后违规、未连接与原理图一致性问题均为 0；线长仍为 442.335515 mm。22 项针对性测试及完整板历史候选更新验证通过，源码/安装包/已安装插件 284 文件一致。

参数差异未减少：9 只电阻、2 组电容仍待工作条件；普通阻容封装及工艺辅助对象仍有差异。比较表已改为读取实际 PCB 的封装、值和接网，12 个工艺辅助符号不再误列为电气拓扑故障。原理图可点选器件填写参数或工作要求，先审查新方案再更新下游。旧项目不会因升级静默改写；修复版副本随本 Demo 提供，后续重新生成自动应用。

## 历史电路设计 0.16.3-beta.16：点选器件填要求，整板评审与自动微调

[Demo 与图纸目录](demos/eda-flow/round-0149) · [下载 Demo 与可编辑工程](demos/eda-flow/round-0149/Demo与工程.zip) · [评审记录](demos/eda-flow/round-0149/工程师评审记录.json) · [AD 逐项比较](demos/eda-flow/round-0149/与AD逐项比较.md) · [使用说明](demos/eda-flow/round-0149/使用说明.md) · [插件 TGZ](dist/dsh-eda-flow-0.16.3-beta.16.tgz) · [SHA256](dist/dsh-eda-flow-0.16.3-beta.16.tgz.sha256)

在原理图点击器件或位号，查看当前值后填写希望的参数、型号或工作要求，选择“按要求生成修改”。电气变化先回到器件推导，确认方案后再更新原理图、BOM 和 PCB；仅图面调整可保留电气设计。保存原话、所选器件、图纸版本、每次运行和复核结果，缺少依据的值保持待确认。

本轮 PCB 阶段真实 DeepSeek 调用 8 次。完整 27 器件、94 物理焊盘；29 个信号网络和全部实际铜形连通，KiCad DRC 错误、警告、未连接与原理图差异均为 0。导出后的可编辑工程再次通过原生 DRC。

相对上一块完整连通板，显式铜线 501.44 → 442.34 mm，短于 0.5 mm 的线段 4 → 3，二度拐点 90 → 70。此前连通候选短段超标，后续新板又出现 GRID3 断点，均未发布。完整连通基线和失败评审均分别保留。供电与返回路径、失败候选和后续修复均保留在 Demo 记录中。

本轮采用来源：重新核验的既有生成候选；已重新生成候选并比较，来源记录随 Demo 提供。

本次重试另修复了候选完成后未及时保存、原生候选共用进程，以及超时原因被普通 stderr 遮盖的问题。新候选独立运行；完整检查点先保存，整轮完成后再发布。相对本条评审开始前，路由变化为 {"trackLengthMm":0,"segments":0,"shortSegmentsUnder05mm":0,"degree2Bends":0}；上面的变化是相对 round-0130 发布基线的累计改进。

新增通用能力包括实际铜形中的局部跨线/接口滤波修复、多个布局候选的有界搜索、共享剩余运行时间、同网接入路径比较，以及保持连通的折线清理。只读取当前生成板的封装、网络、板框与显式工艺约束；没有输入 AD 坐标、外部完整逐脚连接或照抄参数。当前修复限于单布线层、既有跨线器件及局部滤波调整，仍受空间和时间上限约束；一次整板通过不保证任意板都可自动完成。

9 个阻值和 2 组电容组合差异减少 0 项；IRM-3638M3-X 后缀、工作条件、厂家封装与实物性能仍待确认。通过的是本轮连通与布线质量验收，不是 AD 等价或生产批准。45 项原生检查及 22 项评审/流程回归通过；源码、安装包和已安装插件的 284 个文件一致。

重新生成需要 Harness、可用模型、KiCad 完整程序与库、配套 Python 依赖及 Java。Freerouting 随 TGZ 提供。没有 KiCad 时可查看 Demo/PDF，并用 ReviewOnly 记录意见；补齐本机工具后才能生成与核验，目前没有自动远程 CAD 服务。外部规格书与原始 AD 工程不在发布包内。解压 ZIP 后打开 Demo.html；GitHub 的 HTML 文件页显示源码。安装时通过插件 [安装指南](plugins/dsh-eda-flow/docs/engineer-review-and-installation.md) 指定本次 TGZ。

## 历史电路设计 0.16.3-beta.6：完整显示板文字评审与布线复测

[Demo 与图纸目录](demos/eda-flow/round-0130) · [下载 Demo 与可编辑工程](demos/eda-flow/round-0130/Demo与工程.zip) · [评审记录](demos/eda-flow/round-0130/工程师评审记录.json) · [AD 逐项比较](demos/eda-flow/round-0130/与AD逐项比较.md) · [使用说明](demos/eda-flow/round-0130/使用说明.md) · [插件 TGZ](dist/dsh-eda-flow-0.16.3-beta.6.tgz) · [SHA256](dist/dsh-eda-flow-0.16.3-beta.6.tgz.sha256)

本轮 PCB 阶段真实 DeepSeek 调用 6 次、交付阶段 2 次，完整 27 器件/94 物理焊盘经过 6 个实际布线候选，采用第 5 个。C4 所在 STB 接通，独立核验 29 个信号网络全部连通，KiCad DRC 错误、警告、未连接及网表差异均为 0。导出后的可编辑副本再次通过 DRC。

相对此前已连通版，显式铜线 537.192922 → 501.440924 mm，短于 0.5 mm 的线段 5 → 4，折点 97 → 90。评审前的断线版为 477.585689 mm，不能把它和完整连通板的长度直接比较成优化收益。线长不含铜区与器件内部跨线，不代表真实信号/回流性能。

新增通用联合布局允许相关滤波、去耦与储能器件共同选择芯片周围的可行侧，保留板框、器件实际形状、装配面、避让和供电距离。实际断线触发候选，之后重新跑 Freerouting、填铜和 DRC。两个联合重排候选未通过，本轮最终采用的是断线反馈后的普通候选；后续联合压缩候选增加线长而被拒绝。全部记录保留，不把新求解器或单次成功说成普遍保证。Freerouting 2.1 的未固定随机路由顺序仍影响复现性。

没有输入 AD 板坐标、完整逐脚连线或照抄参数。9 个阻值和 2 组电容组合差异本轮减少 0 项；用户确认 IRM-3638M3-X 后缀仍待核实。原理图、准确封装和物理焊盘接网保持；封装测量资料的厂家验证及实物性能仍待工程师复核。此版本通过的是本轮连通与布线质量验收，不是 AD 等价或生产批准。

安装需要 Harness、可用模型、KiCad 10 程序/库与配套 Python 依赖、Java 21。Freerouting 已在 TGZ 内；可选 RapidOCR 的依赖和模型需单独安装。没有 KiCad 可以查看 Demo/PDF，并用 ReviewOnly 记录意见；无法重新生成 CAD 或运行原生 DRC。解压 ZIP 打开 Demo.html 查看交互比较，GitHub 的 HTML 文件页只显示源码。

[安装脚本](plugins/dsh-eda-flow/scripts/install-intranet.ps1) 使用 -SuppliedPackage 指定新 TGZ；[安装指南](plugins/dsh-eda-flow/docs/engineer-review-and-installation.md) 说明 profile 与路径。外部规格书和原始 AD 工程不在发布包中。较早版本和演示结果仍保留为历史记录。

## 工程工作台 0.6.0：拉取后直接更新

[更新步骤与命令](docs/update-workbench-0.6.0.md) · [Release](https://github.com/HlinForest/dsh-plugins/releases/tag/workbench-v0.6.0) · [升级 ZIP](output/packages/Engineering_Workbench_0.6.0.zip) · [插件 TGZ](dist/dsh-engineering-workbench-0.6.0.tgz) · [验证记录](plugins/dsh-engineering-workbench/evals/ui-0.6.0.json)

工作台改为独立窗口，宿主仅保留图标入口；保留原业务导航与操作顺序，标题栏、圆角和分隔对齐 Harness。窗口关闭后保留草稿并暂停界面轮询，后台任务继续；重复点击恢复已有窗口。正式流程继续使用 Harness 当前模型与登录。

已有仓库，在仓库根目录执行以下命令。**工作目录必须替换为原工作台配置中的 workDirectory**，桌面版 profile 通常为 `desktop`：

```powershell
git pull --ff-only origin main
powershell -NoProfile -ExecutionPolicy Bypass -File .\scripts\update-workbench.ps1 -WorkDirectory "D:\原工作台数据目录" -Profile desktop
```

首次拉取使用 `git clone --depth 1 https://github.com/HlinForest/dsh-plugins.git`，再 `cd dsh-plugins` 执行更新命令。本次仓库包含安装包及约 158 MB 的运行时分卷，脚本自动校验、合并并安装，**不需要从 Release 补下载 0.6.0 的窗口运行时**。分卷是普通 Git 文件，不依赖 Git LFS。

升级自动备份旧插件和配置，保留原项目、模型与登录设置；使用带哈希的新包路径避开旧缓存。安装后重新加载插件或在方便时重启 Harness，在工作台“执行记录”核对 **0.6.0 / 32b84f0902abfb3f**。脚本不会强行关闭 Harness，也不调用模型。

本机验证：68 项 Node 测试通过，10 个页面在五种宽度下检查；独立窗口、缩放、全屏、失败重试及配置保留已检查。模型状态使用模拟响应，付费模型请求为零。

## 历史电路设计 dsh-eda-flow 0.3.4：内网资料读取检查

针对点击“整理输入”后 CSV 校验变化：检测 TSD 保护格式，对照 Harness/Node 与 KiCad Python 读取结果；非任务资料异常从第二步阻止执行，保留未改变的任务确认。校验仍严格执行，不解密、不删除保护头、不自动接受变化文件。尚未取得内网诊断，不能断言具体原因就是加密。

移除来源、器件与 BOM 表格里无作用的勾选框，七步都写明“本步操作”和“需要补什么、在哪里补”。第二步直接“整理输入”，不需要勾选来源记录或重传 AD 文件。

```powershell
git pull --ff-only origin main
if ($LASTEXITCODE -ne 0) { throw '拉取失败，请先停止更新' }
powershell -NoProfile -ExecutionPolicy Bypass -File .\scripts\update-eda-flow.ps1 -Profile desktop
```

更新自动备份并保留原项目、模型配置、登录和窗口运行时。等聊天任务结束后正常退出整个 Harness，再重开并点击电路设计图标；只关闭子窗口可能仍是旧后台。

```powershell
powershell -NoProfile -ExecutionPolicy Bypass -File .\scripts\check-eda-flow.ps1 -Profile desktop
```

必须同时得到 **installedVersion 0.3.4 / runningVersion 0.3.4 / activation active**。旧项目可直接在第二步点击“检查资料读取 → 下载诊断记录”，无需查找内部目录。原先已被撤销的第一步需人工重新核对一次。

[更新、诊断与七步操作说明](docs/update-eda-flow-0.3.4.md) · [0.3.4 Release](https://github.com/HlinForest/dsh-plugins/releases/tag/eda-flow-v0.3.4) · [升级 ZIP](output/packages/EDA_Flow_Update_0.3.4.zip) · [插件 TGZ](dist/dsh-eda-flow-0.3.4.tgz) · [验证记录](plugins/dsh-eda-flow/evals/validation-0.3.4.json)

此前 [0.3.3 七步记录](docs/eda-flow-0.3.3-seven-step-validation.md)和[确认与输入入口测试](plugins/dsh-eda-flow/evals/validation-0.3.3.json)继续保留。正式插件使用 Harness 当前模型与登录；本机验证使用模拟响应和实际工具。

[首次安装完整离线包 0.3.1](https://github.com/HlinForest/dsh-plugins/releases/tag/eda-flow-v0.3.1) · [插件安装包](dist/dsh-eda-flow-0.3.1.tgz) · [安装说明](plugins/dsh-eda-flow/docs/intranet.md) · [UI skills](skills/megmeet-dsh-plugin-skills/SKILL.md) · [UI Spec](skills/megmeet-dsh-plugin-skills/references/ui-spec.md) · [验证记录](plugins/dsh-eda-flow/evals/validation-0.3.1.json)

新建设计和显示板示例使用同一套七步流程，无需工程工作台。第一步可由工程师直接确认；后续生成使用 Harness 当前模型，再由工具生成原理图、BOM、PCB 和预览。规格书按页读取并绑定器件；默认输入可查看，阶段确认后再进入下游。

从宿主图标进入三栏独立窗口，保持聊天可用。标题栏为 40px，与顶栏同色，圆角及分隔对齐 Harness；重复打开、执行和重试不会新增项目。正式安装使用真实模型，本机测试使用模拟响应。

已有仓库执行 `git pull --ff-only` 获取源码、插件 TGZ 及 UI skills。`git clone` 不会下载 Release 附件：首次内网安装电路设计 0.3.1 时，可另外下载上述 Release 的 `EDA_Flow_Intranet_0.3.1.zip`，其中包含对应的 Electron 窗口运行时、Python 离线依赖和 UI skills，完整包的安装器会自动部署。上方 0.6.0 自动更新命令仅针对工程工作台，不会更新或替换电路设计插件。

0.3.1 的 14 项 Node 测试及图标交互模拟检查通过；独立窗口、系统按钮、聊天共存及 UI skills 有单独验证记录。此前的真实 KiCad 两个空目录重放和 28 类工程内容比较作为历史工程验证保留；本次 UI 发布没有重跑生成链。真实模型生成质量留到内网验收，本机没有付费模型请求。

工程保留源设计的背面布线和两个铜层设置；生产铜层数与通孔金属化单独待确认。正面阅读预览已增强，实际线宽不变。完整安装包带默认数据和离线依赖，无需历史成品。

## 历史工程复原内网试用版 0.5.0

[完整内网安装包（约 20.6 MB）](output/packages/Engineering_Workbench_Intranet_0.5.0.zip) · [安装与试用说明](plugins/dsh-engineering-workbench/docs/intranet.md) · [SHA-256](output/packages/Engineering_Workbench_Intranet_0.5.0.sha256.txt) · [检查范围与限制](plugins/dsh-engineering-workbench/evals/intranet-0.5.0.json)

已有仓库可执行 `git pull --ff-only`。将完整 ZIP 复制到内网并解压，按说明配置本机路径；安装后打开 **工程工作台 → 工程复原 → 直接读取本机原始文件**。插件内置 Node 运行依赖，ZIP 另带 Windows x64 Python 依赖轮子、安装器及环境检查脚本；Harness 和 KiCad 需预先安装。

当前直接提取支持单页、无层级的 Altium 原理图和一块 PCB，可读取本机 PDF 并绑定器件资料。转换由当前 Harness 模型执行，插件负责资料、独立核验和重放。完整 1:1 与公司正式签核仍需逐项验收，已知差异不会被标成通过。本包不包含账号、原始工程或历史复原答案，模型连接沿用本机 Harness 设置。

工作台源码开发所需的 `dsh-megmeet-0.2.1.tgz` 也在 `dist/` 中，供锁文件安装和回归测试使用；该模块源码的其他改动不在本次发布范围。

2026-10-13 发布前已在独立目录重新安装依赖并完成构建：工作台 65 项 Node 测试、23 项 Python 测试全部通过，安装包与源码及文件哈希一致。

## 工程能力与历史验证

工程工作台按任务独立使用。KiCad 原生 ERC/DRC、两图比较、实际对象编辑、多页候选包及保存回退已实现并测试；AD 支持离线工程读取与候选编辑。**AD 25/26 软件内修改及原生回执仍待接入验收，覆盖 AD 原工程禁用。10 份手册的人工黄金集验收也未完成。**

[六项独立任务分步演示](plugins/dsh-engineering-workbench/docs/independent-demo.md)包含小工程、点击顺序、预期结果和回退方法；[验证与待验收项](plugins/dsh-engineering-workbench/docs/validation.md)列出实际覆盖。旧版演示材料仍保留，使用新版请优先看六项任务文档。

## 安装

克隆本公开仓库后，在仓库根目录按需安装 `dist/` 中的包。`web` 替换为实际使用的 DSH profile。已有工程工作台请优先使用上方的更新脚本，以保留配置并部署独立窗口运行时。

```powershell
git clone https://github.com/HlinForest/dsh-plugins.git
cd dsh-plugins
dsh plugin --profile web add ./dist/dsh-megmeet-0.2.0.tgz
dsh plugin --profile web add ./dist/dsh-pcb-review-0.1.2.tgz
dsh plugin --profile web add ./dist/dsh-schematic-sync-0.1.2.tgz
dsh plugin --profile web add ./dist/dsh-kicad-workflow-0.1.1.tgz
dsh plugin --profile web add ./dist/dsh-engineering-workbench-0.6.0.tgz
```

按各插件 README 设置目录、KiCad CLI / Python / MCP Server 等本机配置，然后重新加载对应 profile。源码 README 保留了原开发机的路径示例；换机器或移动目录后需要调整。插件没有另设模型登录入口。

## 源码开发与打包

各插件分别管理依赖和锁文件。在对应目录安装、测试与打包，例如：

```powershell
cd plugins/dsh-megmeet
npm ci --ignore-scripts
npm test
npm pack --pack-destination ../../dist
```

`dsh-megmeet` 的测试命令会先编译 TypeScript；生成的 `lib/` 不纳入源码版本控制，但已包含在安装包中。其他插件使用 JavaScript 源码。`npm pack` 会执行各自的 `prepack` 检查。

`verify:live`、桌面安装和模型对比演示依赖本机 DSH / KiCad 环境；普通单元与运行时测试不代替这些实际联调。

### 2026-10-10 历史版本验证

2026-10-10 在 Windows、Node.js 24.19.0、npm 11.17.0 环境完成检查：

| 插件 | 通过 | 失败 / 跳过 |
| --- | --- | --- |
| dsh-megmeet | 42 | 0 / 0 |
| dsh-pcb-review | 21 | 0 / 0 |
| dsh-schematic-sync | 22 | 0 / 0 |
| dsh-kicad-workflow | 15 | 0 / 0 |
| dsh-engineering-workbench | 38 | 0 / 0 |
| 合计 | 138 | 0 / 0 |

`dist/` 安装包从通过检查的源码生成，SHA256 见 [dist/SHA256SUMS.txt](dist/SHA256SUMS.txt)。旧版压缩包保留供回退，安装时使用上表对应的新版本。

此前 0.2 系列工作台在实际 DSH 0.2.0-rc.2 原生 Web 界面完成 24 个业务动作联调：真实 48V 客户需求解析、检索、复核、报告三格式导出及 HTML 筛选/资料链接；工程导出、器件网络、检查清单、输入快照、监听启停；文字、原生 KiCad 和 PDF 目标、多项修改、前后图、ERC、确认写回和回退。另检查草稿保留、过期结果失效、浮动面板和窄屏显示。浏览器无页面异常。

写回与回退只在独立测试工程执行，回退后文件逐字节一致，原工程 SHA256 未变。此前四个业务插件共有 30 个原生工具，新版工作台另提供独立 engineering_task 工具，另可接入 KiCad MCP；注册数量不代表每个硬件操作均已实测。自动视觉识别现在接入 DSH 当前默认图片模型，沿用登录；也支持显式配置独立视觉接口。纯文字模型、配置不完整或识别失败会显示原因，未知项继续阻止写回。已用实际 JPEG 在本机 DSH 登录下完成图片识别和工作台草稿回填；识别值仍需逐条人工核对，模型不会代替用户勾选确认。

工作台 0.2.2 修复 SVG 焦点外框随坐标缩放造成的器件放大，以及空白点击和异步旧查询造成的残留选择。原生浏览器回归覆盖 100% / 200% 缩放、键盘、取消选择和乱序查询。原理图增加实际修改清单、导线 / 标注高亮、两侧分别定位、同步缩放 / 拖动、全屏与目标原件对照；已在实际 DSH 中验证。

## 三个插件的独立演示

[15 页分步演示手册](output/pdf/DSH三个插件独立演示手册.pdf)包含实测截图、点击顺序、预期结果、现场讲解参考和复位方法。三个案例可以分别开始：真实需求选型、四器件 PCB 评审、独立原理图改值及回退。

[完整演示材料包](output/packages/DSH三个插件独立演示材料包.zip)包含手册、输入文本、KiCad 小工程、预制修正版、插件安装包、选型资料原件和启动入口。解压后阅读“开始这里.txt”，双击“打开演示工作台.cmd”即可使用独立 DSH 演示配置。需要本机已安装兼容的 DSH、KiCad 和 Python；当前开发机已准备完成。

可编辑材料和复现脚本位于 [demos/independent](demos/independent)。实跑结果：提高负载和温度后保留 4 个满足已列条件的候选；PCB 由 1 项需处理变为 2 项局部检查符合；原理图两处改值后目标差异为 0、ERC 为 0 错误及 0 警告，回退恢复文件逐字节一致。小板尚未布线，用于教学展示，不作为生产设计。

## 收录范围

本仓库于 2026-10-10 从本地四个插件项目整理，并新增原生工程工作台。保留源码、测试、依赖锁文件、配置示例、脚本、许可证，以及资料库演示使用的公开资料、快照、静态演示页和报告。

本机依赖、登录/profile 文件、原始会话与运行记录、临时工作目录、权限恢复备份和历史压缩包不收录。演示文档中的 `records/`、`runs/`、`verification/` 等历史证据路径属于原本地交付目录；需要这些记录的实验汇总或页面重建步骤，应先在自己的环境重新生成。演示页中的旧绝对路径也可能需要调整。

`dsh-megmeet/success-demo/materials/` 和 `snapshots/` 是真实资料校验测试的输入，必须一起保留。打包的插件只包含各自 `package.json` 声明的运行文件；使用真实资料库时，将所需资料保留在本机，并通过管理员配置指定资料库路径。

## 许可证

各插件源代码沿用各目录中的 MIT 许可证。演示中的厂家 PDF、网页摘录与其他第三方资料保留原来源和权利归属，不适用插件代码的 MIT 授权。

## KiCad design demos/eda-flow/round-0125/修改前/Circuit.kicad_pcb

Parts:
C1: 100nF; C_0805_2012Metric
C2, C3, C4: 100pF; C_0805_2012Metric
C5: 1µF; C_0805_2012Metric
C6: 10µF; C_0805_2012Metric
D1: IRM-3638M3-X; FP_c783efe2c5902037
DISP: 6Pin/2.5mm; FP_87693eea20e7eb47
DS1: LED; FP_50ea157fbcd408b9
R1, R2, R3, R4, R5, R6, R7: 330Ω; R_0805_2012Metric
R8: 100Ω; R_0805_2012Metric
R9: 10kΩ; R_0805_2012Metric
R10, R11, R12, R13, R14, R15, R16, R17: 0Ω; R_0805_2012Metric
U1: TM1616; FP_abf73c9ba269dea0

Connections:
/+5V: C1.1, C6.1, DISP.3, R8.1, R9.1, U1.4 (VDD)
/CLK: C3.1, R11.2, U1.2 (CLK)
/CLK_DISP: DISP.5, R11.1
/DIG1: DS1.3 (DIG1), R15.2
/DIG2: DS1.2 (DIG2), R16.2
/DIG3: DS1.1 (DIG3), R14.2
/DIN: C2.1, R10.2, U1.1 (DIN)
/DIN_DISP: DISP.6, R10.1
/GRID1: R14.1, U1.16 (GRID1)
/GRID2: R15.1, U1.15 (GRID2)
/GRID3: R16.1, U1.13 (GRID3)
/IRM_OUT: D1.1 (OUT), R9.2, R13.1
/LED_A: DS1.5 (A), R6.2
/LED_B: DS1.4 (B), R7.2
/LED_C: DS1.8 (C), R1.2
/LED_D: DS1.10 (D), R4.2
/LED_E: DS1.9 (E), R2.2
/LED_F: DS1.6 (F), R5.2
/LED_G: DS1.7 (G), R3.2
/RCV: DISP.1, R13.2
/SEG1: R1.1, U1.5 (SEG1)
/SEG2: R2.1, U1.6 (SEG2)
/SEG3: R3.1, U1.7 (SEG3)
/SEG4: R4.1, U1.8 (SEG4)
/SEG5: R5.1, U1.9 (SEG5)
/SEG6: R6.1, U1.10 (SEG6)
/SEG7: R7.1, U1.11 (SEG7)
/SGND: DISP.2, R17.1
/STB: C4.1, R12.2, U1.3 (STB)
/STB_DISP: DISP.4, R12.1

Notes on the sheet:
接口与局部电路
驱动与滤波
显示模块

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
Board: 2 copper layers, 82.5 x 57.5 mm, 27 parts (24 on the bottom side), 32 nets.

File demos/eda-flow/round-0125/修改后/bom.csv:

Reference,Value,Footprint,MPN,DesignId,OriginalFootprint,MaterialCode,MaterialDescription,AssemblyType,ObjectRole,DNP,OnBoard
U1,TM1616,,,fact-acb1ef47066f4a92-U1,WSOP16-1.27-3.8,R25070026,CMOS逻辑器件/TM1616/5V/-20~+70 degC/SOP-16/共阴极LED驱动控制专用电路,SMD,electrical,False,True
D1,IRM-3638M3-X,,,fact-b0a33beccc463cf7-D1,LED3-2.54-6*5.6*6.95L/S,R25090022,接口收发器/红外接收管/IRM-3638M3-X/38KHZ/5.5V/0.6mA/-20~+80 degC,THT,electrical,False,True
DISP,6Pin/2.5mm,,,fact-0ffa6529256614c4-DISP,THT-CON6-2.5-6.4L/S,R30072135,电缆/MD-12K-D-1/灯板连接线/26AWG/750mm/黑白橙绿紫灰/SM-6P/SM-T/MEG-150446,THT,electrical,False,True
DS1,LED,,,fact-6a92ebe087d6003e-DS1,UV,,显示模块，两位七段数字与四个圆形指示标记；制造商/采购订货号未提供。,,electrical,False,True
R1,330Ω,Resistor_SMD:R_0805_2012Metric,,R1,,,,,,False,True
R2,330Ω,Resistor_SMD:R_0805_2012Metric,,R2,,,,,,False,True
R3,330Ω,Resistor_SMD:R_0805_2012Metric,,R3,,,,,,False,True
R4,330Ω,Resistor_SMD:R_0805_2012Metric,,R4,,,,,,False,True
R5,330Ω,Resistor_SMD:R_0805_2012Metric,,R5,,,,,,False,True
R6,330Ω,Resistor_SMD:R_0805_2012Metric,,R6,,,,,,False,True
R7,330Ω,Resistor_SMD:R_0805_2012Metric,,R7,,,,,,False,True
R8,100Ω,Resistor_SMD:R_0805_2012Metric,,R8,,,,,,False,True
R9,10kΩ,Resistor_SMD:R_0805_2012Metric,,R9,,,,,,False,True
R10,0Ω,Resistor_SMD:R_0805_2012Metric,,R10,,,,,,False,True
R11,0Ω,Resistor_SMD:R_0805_2012Metric,,R11,,,,,,False,True
R12,0Ω,Resistor_SMD:R_0805_2012Metric,,R12,,,,,,False,True
R13,0Ω,Resistor_SMD:R_0805_2012Metric,,R13,,,,,,False,True
R14,0Ω,Resistor_SMD:R_0805_2012Metric,,R14,,,,,,False,True
R15,0Ω,Resistor_SMD:R_0805_2012Metric,,R15,,,,,,False,True
R16,0Ω,Resistor_SMD:R_0805_2012Metric,,R16,,,,,,False,True
R17,0Ω,Resistor_SMD:R_0805_2012Metric,,R17,,,,,,False,True
C1,100nF,Capacitor_SMD:C_0805_2012Metric,,C1,,,,,,False,True
C2,100pF,Capacitor_SMD:C_0805_2012Metric,,C2,,,,,,False,True
C3,100pF,Capacitor_SMD:C_0805_2012Metric,,C3,,,,,,False,True
C4,100pF,Capacitor_SMD:C_0805_2012Metric,,C4,,,,,,False,True
C5,1µF,Capacitor_SMD:C_0805_2012Metric,,C5,,,,,,False,True
C6,10µF,Capacitor_SMD:C_0805_2012Metric,,C6,,,,,,False,True

## KiCad design examples/display-board-20261015/DisplayBoard/DisplayBoard.kicad_pcb

File examples/display-board-20261015/README.md:

# 显示板：已生成的 KiCad 工程

这是 2026-10-15 在电路设计插件 0.3.4 的独立窗口中，逐步执行显示板默认输入得到的工程。可以直接用 KiCad 打开，无需安装或运行 Harness 插件。工程、库、模型和预览均在本目录中，Git 拉取会一起取得。

## 打开工程

在已有仓库目录执行：

```powershell
git pull --ff-only origin main
```

随后用 KiCad 打开 `examples/display-board-20261015/DisplayBoard/DisplayBoard.kicad_pro`。生成和检查使用的 KiCad 版本为 **10.0.6**；若旧版提示文件格式过新，需使用支持该格式的版本。

- 原理图：`DisplayBoard/DisplayBoard.kicad_sch`
- PCB：`DisplayBoard/DisplayBoard.kicad_pcb`
- BOM：`DisplayBoard/BOM_逐位号.csv`
- 符号库、封装库：`DisplayBoard_Native.kicad_sym`、`DisplayBoard_Placed.pretty/`，以及两份库表。
- 三维模型：`DisplayBoard/models/`，通过工程相对路径关联。
- 原理图 PDF：`DisplayBoard/previews/schematic.pdf`
- 正反面及三维预览：`DisplayBoard/previews/`

请完整保留 `DisplayBoard` 目录，不要只移动原理图或 PCB 单个文件。只看图纸可以直接打开 PDF 或 SVG。

## 是否由 KiCad 直接导入 AD 得到

**本轮生成阶段没有调用 AD 导入器，也没有读取 SchDoc/PcbDoc。**

原理图由 `generate_schematic.py` 读取原始提取记录、器件、引脚、符号图形、连接和页面坐标，创建新的 KiCad 原理图及符号库。PCB 由 `generate_pcb.py` 从空的 KiCad 文件结构开始，按默认输入逐个创建封装、焊盘、走线、铜区和其他对象，再应用已确认的调整。

需要区分输入的历史来源：**PCB 默认输入中部分图元曾借助 KiCad 官方 AD 导入器作为辅助提取通道，并与已确认原工程的导入结果核对。** 所以不能把本工程描述为“资料准备全过程没有使用导入器”，也不能当作“仅凭需求让 AI 从零设计出了同一块板”。

本次模型环节使用 12 次模拟响应，真实模型请求为零；实际生成由已编写的 Python/KiCad 工具完成。它验证默认输入与工具链可生成工程，不代表真实 DeepSeek 独立设计能力已通过验证。

## 结果与来源记录

七步均已确认，第一步确认及结果哈希保留；显示板基准的 28 类内容比较一致。交付仍为带待确认项的草稿：厂家规格书、原 AD 编译网表及页面 PDF、数码管原始三维模型尚缺，制造铜层数和孔金属化待确认；最终 ERC 1 条警告、DRC 40 条警告。详见工程 `checks/` 和 `evidence/seven-step-validation.json`。

- `evidence/generation-method.json`：生成路径、模型方式、历史输入来源与待办。
- `evidence/commands.json`：本轮实际生成、导出、检查命令；本机绝对路径已替换为占位符。
- `evidence/published-files.json`：交付文件哈希。
- `DisplayBoard/checks/file-access-*.json`：Python 文件读取记录。记录范围不含原生 C++ 内部文件读写。

工程主体、BOM、库、模型及预览与本轮生成结果字节一致。公开副本只整理检查记录中的本机路径，并省略个人视图文件 `.kicad_prl`；原始运行记录在本机保留。

[生成器源码（本轮固定版本）](https://github.com/HlinForest/dsh-plugins/tree/9a19d1c2167fdb66da5ab6dcd0f87bf79fbcf714/plugins/dsh-eda-flow/python/structured) · [独立工程下载包](https://github.com/HlinForest/dsh-plugins/releases/tag/display-board-20261015)

Parts:
*: LED; __Original
C1: 0.068uF/0603; C1_Original
C2: 1uF/0603; C2_Original
C3: 0.068uF/0603; C3_Original
C4: 4.7uF/16V; C4_Original
C5: 100pF/0603; C5_Original
C6: 100pF/0603; C6_Original
C7: 100pF/0603; C7_Original
C8: 4.7uF/16V; C8_Original
D1: IRM-3638M3-X; D1_Original
DISP: 6Pin/2.5mm; DISP_Original
DWK1: .; DWK1_Original
DWK2: .; DWK2_Original
LLAA: .; LLAA_Original
LLOO: .; LLOO_Original
MM1: .; MM1_Original
MM2: .; MM2_Original
MM3: .; MM3_Original
QR Code: .
QR Code1: .; QR_Code1_Original
R1: 220R/0805; R1_Original
R2: 47R/0805; R2_Original
R3: 22K/0805; R3_Original
R4: 47R/0805; R4_Original
R5: 47R/0603; R5_Original
R6: 47R/0805; R6_Original
R7: 47R/0603; R7_Original
R8: 47R/0805; R8_Original
R9: 47R/0603; R9_Original
RJ1: 0R/0805; RJ1_Original
RJ2: 0R/0805; RJ2_Original
RJ3: 0R/0805; RJ3_Original
RJ4: 0R/0805; RJ4_Original
RJ5: 0R/0805; RJ5_Original
RJ6: 0R/0805; RJ6_Original
RJ7: 0R/0805; RJ7_Original
RJ8: 0R/1206; RJ8_Original
SS: .; SS_Original
U1: TM1616; U1_Original
UL: .; UL_Original
check: .; check_Original

Connections:
/+5V: C1.1, C4.2, C8.2, DISP.3, R1.2, R3.2, U1.4 (VDD)
/A: *.5 (A), R7.2
/B: *.4 (B), R5.2
/C: *.8 (C), R2.1
/CLK: C6.2, DISP.5, RJ5.1, RJ5.2, RJ6.1, RJ6.2, U1.2 (CLK)
/D: *.10 (D), R8.1
/DIN: C7.2, DISP.6, U1.1 (DIN)
/E: *.9 (E), R4.1
/F: *.6 (F), R9.2
/G: *.7 (G), R6.1
/G1: *.1 (DIG3), RJ2.1, RJ2.2, U1.16 (GRID1)
/G2: *.3 (DIG1), RJ8.1, RJ8.2, U1.15 (GRID2)
/G3: *.2 (DIG2), RJ1.1, RJ1.2, U1.13 (GRID3)
/RCV: D1.1 (OUT), DISP.1, R3.1
/SGND: C1.2, C2.1, C3.1, C4.1, C5.1, C6.1, C7.1, C8.1, D1.2 (GND), DISP.2, RJ3.1, RJ3.2, RJ4.1, RJ4.2, RJ7.1, RJ7.2, U1.14 (GND)
/STB: C5.2, DISP.4, U1.3 (STB)
unnamed: C2.2, C3.2, D1.3 (VCC), R1.1
unnamed: R2.2, U1.5 (SEG1)
unnamed: R4.2, U1.6 (SEG2)
unnamed: R6.2, U1.7 (SEG3)
unnamed: R8.2, U1.8 (SEG4)
unnamed: R9.1, U1.9 (SEG5)
unnamed: R7.1, U1.10 (SEG6)
unnamed: R5.1, U1.11 (SEG7)

Notes on the sheet:
DIN
CLK
STB
+5V
SGND
RCV
Display board Interface

Board: 2 copper layers, 82.5 x 57.5 mm, 40 parts (34 on the bottom side), 24 nets.

## KiCad design demos/independent/02-pcb/after/FilterReview.kicad_pcb

Parts:
C1: 100nF; C_0805_2012Metric
J1: INPUT; PinHeader_1x02_P2.54mm_Vertical
J2: OUTPUT; PinHeader_1x02_P2.54mm_Vertical
R1: 1k; R_0805_2012Metric

Connections:
GND: C1.2, J1.2, J2.2
SIGNAL: C1.1, J2.1, R1.2
VIN: J1.1, R1.1

Notes on the sheet:
RC input review: C1 is omitted in the baseline.

Board: 2 copper layers, 4 parts (0 on the bottom side), 3 nets, no tracks yet.
